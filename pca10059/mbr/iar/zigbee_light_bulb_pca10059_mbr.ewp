# IAR project zigbee_light_bulb_pca10059_mbr.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BOARD_PCA10059; CONFIG_GPIO_AS_PINRESET; ENABLE_FEM; FLOAT_ABI_HARD; MBR_PRESENT; NRF52840_XXAA; SWI_DISABLE0; ZB_TRACE_LEVEL=0; ZB_TRACE_MASK=0
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\..\components; ..\..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\..\..\components\libraries\gpiote; ..\..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\..\..\components\libraries\pwm; ..\..\..\..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\components\softdevice\mbr\nrf52840\headers; ..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\..\components\zigbee\common; ..\..\..\..\..\app_utils\ws2812; ..\..\..; ..\..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src; ..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem; ..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\mac_features; ..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\mac_features\ack_generator; ..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\rsch; ..\..\..\..\..\..\..\external\zboss\addons; ..\..\..\..\..\..\..\external\zboss\include; ..\..\..\..\..\..\..\external\zboss\include\ha; ..\..\..\..\..\..\..\external\zboss\include\osif; ..\..\..\..\..\..\..\external\zboss\include\zcl; ..\..\..\..\..\..\..\external\zboss\osif; ..\..\..\..\..\..\..\external\zboss\zb_error; ..\..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: zigbee_light_bulb_pca10059_mbr.hex
  ILINK.IlinkOutputFile: zigbee_light_bulb_pca10059_mbr.out
  ILINK.IlinkIcfFile: zigbee_light_bulb_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../../components/libraries/bsp/: bsp.c
  group Example
    ../../../../../app_utils/ws2812/: drv_ws2812.c
  group None
    ../../../../../../../modules/nrfx/mdk/: iar_startup_nrf52840.s system_nrf52840.c
  group nRF_Drivers
    ../../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_ppi.c nrf_drv_rng.c nrf_drv_uart.c
    ../../../../../../../modules/nrfx/hal/: nrf_ecb.c nrf_nvmc.c
    ../../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_ppi.c nrfx_pwm.c nrfx_rng.c nrfx_systick.c nrfx_timer.c nrfx_uart.c nrfx_uarte.c
    ../../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_util_platform.c nrf_assert.c
    ../../../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../../../components/libraries/pwm/: app_pwm.c
    ../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../components/libraries/assert/: assert.c
    ../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c
    ../../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Zigbee
    ../../../../../../../components/zigbee/common/: zigbee_helpers.c zigbee_logger_eprxzcl.c
  group Zigbee
    ../../../../../../../external/zboss/lib/iar/: libzboss.a nrf_radio_driver.a
    ../../../../../../../external/zboss/zb_error/: zb_error_to_string.c
    ../../../../../../../external/zboss/osif/: zb_nrf52840_common.c zb_nrf52840_nrf_logger.c zb_nrf52840_nvram.c zb_nrf52840_ota.c zb_nrf52840_sdk_config_deps.c zb_nrf52840_timer.c
    ../../../../../../../external/zboss/addons/zcl/: zb_zcl_common_addons.c zb_zcl_ota_upgrade_addons.c
